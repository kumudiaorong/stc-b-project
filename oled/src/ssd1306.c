#include "ssd1306.h"

#include "iic.h"

#define __SSD1306_SCL P1_1
#define __SSD1306_SDA P1_0
#define __SSD1306_DEVICE_ADDR 0x3C
__XSL_IIC_GEN_BASE(__SSD1306_SCL, __SSD1306_SDA, NOP)
__XSL_IIC_GEN_WRITE_BYTE(__SSD1306_SCL, __SSD1306_SDA, NOP)
__XSL_IIC_GEN_READ_BYTE(__SSD1306_SCL, __SSD1306_SDA, NOP)
__XSL_IIC_GEN_WRITE_ADDR_BYTE(static, __iic_write_addr_byte, 0x3C)

__XSL_IIC_GEN_READ_ADDR_BYTE(static, __iic_read_addr_byte, 0x3C)

#define __SSD1306_COMMAND 0x00
#define __SSD1306_DATA 0x40
#define __SSD1306_ONLY_DATA 0x00
#define __SSD1306_MIX 0x80

#define __SSD1306_SetDisplayOn 0xAF
#define __SSD1306_SetDisplayOff 0xAE
#define __SSD1306_SetLowerColumnStartAddForPageMode 0x00
#define __SSD1306_SetHigherColumnStartAddForPageMode 0x10
#define __SSD1306_SetDisplayStartLine 0x40
#define __SSD1306_SetContrastControlRegister 0x81
#define __SSD1306_SetSegmentRemapToNormal 0xA0
#define __SSD1306_SetSegmentRemapToReverse 0xA1
#define __SSD1306_SetColumnRemapToNormal 0xA0
#define __SSD1306_SetColumnRemapToReverse 0xA1
#define __SSD1306_SetCOMOutputScanDirectionToNormal 0xC8
#define __SSD1306_SetCOMOutputScanDirectionToReverse 0xC0
#define __SSD1306_SetRowRemapToNormal 0xC0
#define __SSD1306_SetRowRemapToReverse 0xC8
#define __SSD1306_SetNormalDisplay 0xA6
#define __SSD1306_SetInverseDisplay 0xA7
#define __SSD1306_SetMultiplexRatio 0xA8
#define __SSD1306_SetDisplayOffset 0xD3
#define __SSD1306_SetDisplayClockDivideRatioAndOscillatorFrequency 0xD5
#define __SSD1306_SetPrechargePeriod 0xD9
#define __SSD1306_SetCOMPinHardwareConfiguration 0xDA
#define __SSD1306_SetVCOMHDeselectLevel 0xDB
#define __SSD1306_SetAddressingMode 0x20
#define __SSD1306_SetEntireDisplayOn 0xA4
#define __SSD1306_SetChargePumpSetting 0x8D

uint8_t CODE asc2_0806[][6] = {
  {0x00, 0x00, 0x00, 0x00, 0x00, 0x00}, // sp
  {0x00, 0x00, 0x00, 0x2f, 0x00, 0x00}, // !
  {0x00, 0x00, 0x07, 0x00, 0x07, 0x00}, // "
  {0x00, 0x14, 0x7f, 0x14, 0x7f, 0x14}, // #
  {0x00, 0x24, 0x2a, 0x7f, 0x2a, 0x12}, // $
  {0x00, 0x62, 0x64, 0x08, 0x13, 0x23}, // %
  {0x00, 0x36, 0x49, 0x55, 0x22, 0x50}, // &
  {0x00, 0x00, 0x05, 0x03, 0x00, 0x00}, // '
  {0x00, 0x00, 0x1c, 0x22, 0x41, 0x00}, // (
  {0x00, 0x00, 0x41, 0x22, 0x1c, 0x00}, // )
  {0x00, 0x14, 0x08, 0x3E, 0x08, 0x14}, // *
  {0x00, 0x08, 0x08, 0x3E, 0x08, 0x08}, // +
  {0x00, 0x00, 0x00, 0xA0, 0x60, 0x00}, // ,
  {0x00, 0x08, 0x08, 0x08, 0x08, 0x08}, // -
  {0x00, 0x00, 0x60, 0x60, 0x00, 0x00}, // .
  {0x00, 0x20, 0x10, 0x08, 0x04, 0x02}, // /
  {0x00, 0x3E, 0x51, 0x49, 0x45, 0x3E}, // 0
  {0x00, 0x00, 0x42, 0x7F, 0x40, 0x00}, // 1
  {0x00, 0x42, 0x61, 0x51, 0x49, 0x46}, // 2
  {0x00, 0x21, 0x41, 0x45, 0x4B, 0x31}, // 3
  {0x00, 0x18, 0x14, 0x12, 0x7F, 0x10}, // 4
  {0x00, 0x27, 0x45, 0x45, 0x45, 0x39}, // 5
  {0x00, 0x3C, 0x4A, 0x49, 0x49, 0x30}, // 6
  {0x00, 0x01, 0x71, 0x09, 0x05, 0x03}, // 7
  {0x00, 0x36, 0x49, 0x49, 0x49, 0x36}, // 8
  {0x00, 0x06, 0x49, 0x49, 0x29, 0x1E}, // 9
  {0x00, 0x00, 0x36, 0x36, 0x00, 0x00}, // :
  {0x00, 0x00, 0x56, 0x36, 0x00, 0x00}, // ;
  {0x00, 0x08, 0x14, 0x22, 0x41, 0x00}, // <
  {0x00, 0x14, 0x14, 0x14, 0x14, 0x14}, // =
  {0x00, 0x00, 0x41, 0x22, 0x14, 0x08}, // >
  {0x00, 0x02, 0x01, 0x51, 0x09, 0x06}, // ?
  {0x00, 0x32, 0x49, 0x59, 0x51, 0x3E}, // @
  {0x00, 0x7C, 0x12, 0x11, 0x12, 0x7C}, // A
  {0x00, 0x7F, 0x49, 0x49, 0x49, 0x36}, // B
  {0x00, 0x3E, 0x41, 0x41, 0x41, 0x22}, // C
  {0x00, 0x7F, 0x41, 0x41, 0x22, 0x1C}, // D
  {0x00, 0x7F, 0x49, 0x49, 0x49, 0x41}, // E
  {0x00, 0x7F, 0x09, 0x09, 0x09, 0x01}, // F
  {0x00, 0x3E, 0x41, 0x49, 0x49, 0x7A}, // G
  {0x00, 0x7F, 0x08, 0x08, 0x08, 0x7F}, // H
  {0x00, 0x00, 0x41, 0x7F, 0x41, 0x00}, // I
  {0x00, 0x20, 0x40, 0x41, 0x3F, 0x01}, // J
  {0x00, 0x7F, 0x08, 0x14, 0x22, 0x41}, // K
  {0x00, 0x7F, 0x40, 0x40, 0x40, 0x40}, // L
  {0x00, 0x7F, 0x02, 0x0C, 0x02, 0x7F}, // M
  {0x00, 0x7F, 0x04, 0x08, 0x10, 0x7F}, // N
  {0x00, 0x3E, 0x41, 0x41, 0x41, 0x3E}, // O
  {0x00, 0x7F, 0x09, 0x09, 0x09, 0x06}, // P
  {0x00, 0x3E, 0x41, 0x51, 0x21, 0x5E}, // Q
  {0x00, 0x7F, 0x09, 0x19, 0x29, 0x46}, // R
  {0x00, 0x46, 0x49, 0x49, 0x49, 0x31}, // S
  {0x00, 0x01, 0x01, 0x7F, 0x01, 0x01}, // T
  {0x00, 0x3F, 0x40, 0x40, 0x40, 0x3F}, // U
  {0x00, 0x1F, 0x20, 0x40, 0x20, 0x1F}, // V
  {0x00, 0x3F, 0x40, 0x38, 0x40, 0x3F}, // W
  {0x00, 0x63, 0x14, 0x08, 0x14, 0x63}, // X
  {0x00, 0x07, 0x08, 0x70, 0x08, 0x07}, // Y
  {0x00, 0x61, 0x51, 0x49, 0x45, 0x43}, // Z
  {0x00, 0x00, 0x7F, 0x41, 0x41, 0x00}, // [
  {0x00, 0x55, 0x2A, 0x55, 0x2A, 0x55}, // 55
  {0x00, 0x00, 0x41, 0x41, 0x7F, 0x00}, // ]
  {0x00, 0x04, 0x02, 0x01, 0x02, 0x04}, // ^
  {0x00, 0x40, 0x40, 0x40, 0x40, 0x40}, // _
  {0x00, 0x00, 0x01, 0x02, 0x04, 0x00}, // '
  {0x00, 0x20, 0x54, 0x54, 0x54, 0x78}, // a
  {0x00, 0x7F, 0x48, 0x44, 0x44, 0x38}, // b
  {0x00, 0x38, 0x44, 0x44, 0x44, 0x20}, // c
  {0x00, 0x38, 0x44, 0x44, 0x48, 0x7F}, // d
  {0x00, 0x38, 0x54, 0x54, 0x54, 0x18}, // e
  {0x00, 0x08, 0x7E, 0x09, 0x01, 0x02}, // f
  {0x00, 0x18, 0xA4, 0xA4, 0xA4, 0x7C}, // g
  {0x00, 0x7F, 0x08, 0x04, 0x04, 0x78}, // h
  {0x00, 0x00, 0x44, 0x7D, 0x40, 0x00}, // i
  {0x00, 0x40, 0x80, 0x84, 0x7D, 0x00}, // j
  {0x00, 0x7F, 0x10, 0x28, 0x44, 0x00}, // k
  {0x00, 0x00, 0x41, 0x7F, 0x40, 0x00}, // l
  {0x00, 0x7C, 0x04, 0x18, 0x04, 0x78}, // m
  {0x00, 0x7C, 0x08, 0x04, 0x04, 0x78}, // n
  {0x00, 0x38, 0x44, 0x44, 0x44, 0x38}, // o
  {0x00, 0xFC, 0x24, 0x24, 0x24, 0x18}, // p
  {0x00, 0x18, 0x24, 0x24, 0x18, 0xFC}, // q
  {0x00, 0x7C, 0x08, 0x04, 0x04, 0x08}, // r
  {0x00, 0x48, 0x54, 0x54, 0x54, 0x20}, // s
  {0x00, 0x04, 0x3F, 0x44, 0x40, 0x20}, // t
  {0x00, 0x3C, 0x40, 0x40, 0x20, 0x7C}, // u
  {0x00, 0x1C, 0x20, 0x40, 0x20, 0x1C}, // v
  {0x00, 0x3C, 0x40, 0x30, 0x40, 0x3C}, // w
  {0x00, 0x44, 0x28, 0x10, 0x28, 0x44}, // x
  {0x00, 0x1C, 0xA0, 0xA0, 0xA0, 0x7C}, // y
  {0x00, 0x44, 0x64, 0x54, 0x4C, 0x44}, // z
  {0x14, 0x14, 0x14, 0x14, 0x14, 0x14}, // horiz lines
};

void ssd1306_set_pos(uint8_t x, uint8_t y) REENTRANT {
  __iic_start();
  __ASSERT_RETURN(!__iic_write_byte(__SSD1306_DEVICE_ADDR << 1), );
  __ASSERT_RETURN(!__iic_write_byte(__SSD1306_ONLY_DATA | __SSD1306_COMMAND), );
  __ASSERT_RETURN(!__iic_write_byte(0xb0 + y), );
  __ASSERT_RETURN(!__iic_write_byte((x >> 4) | 0x10), );
  __ASSERT_RETURN(!__iic_write_byte(x & 0x0f), );
  __iic_stop();
}
static XDATA uint8_t ssd1306_gddram[128 * 8];
void ssd1306_clear(void) REENTRANT {
  uint16_t i;
  for(i = 0; i < 128 * 8; i++) {
    ssd1306_gddram[i] = 0x00;
  }
}

static void ssd1306_row_draw_part(uint16_t pos, uint8_t len, uint8_t mask, uint8_t row[]) REENTRANT {
  uint8_t i;
  for(i = 0; i < len; i++) {
    ssd1306_gddram[pos + i] = (ssd1306_gddram[pos + i] & mask) | (row[i] & (~mask));
  }
}
void ssd1306_draw_bmp(uint8_t x, uint8_t y, uint8_t sizex, uint8_t sizey, uint8_t bmp[]) REENTRANT {
  if(y % 8 != 0) {
    ssd1306_row_draw_part((y / 8) * 128 + x, sizex, ~(0xff << (y % 8)), bmp);
    sizey -= 8 - (y % 8);
    y = (y + 8) & 0xf8;
    bmp += sizex;
  }
  while(sizey > 7) {
    ssd1306_row_draw_part((y / 8) * 128 + x, sizex, 0, bmp);
    sizey -= 8;
    y += 8;
    bmp += sizex;
  }
  if(sizey > 0) {
    ssd1306_row_draw_part((y / 8) * 128 + x, sizex, 0xff << (8 - sizey), bmp);
  }
}
void ssd1306_update(uint8_t x, uint8_t y, uint8_t sizex, uint8_t sizey) REENTRANT {
  uint8_t i, j;
  sizey = ((y + sizey) >> 3) + (((y + sizey) & 0x07) ? 1 : 0);
  y >>= 3;
  for(i = 0; i < sizey; i++) {
    ssd1306_set_pos(x, y + i);
    __iic_start();
    __ASSERT_RETURN(!__iic_write_byte(__SSD1306_DEVICE_ADDR << 1), );
    __ASSERT_RETURN(!__iic_write_byte(__SSD1306_ONLY_DATA | __SSD1306_DATA), );
    for(j = 0; j < sizex; j++) {
      __ASSERT_RETURN(!__iic_write_byte(ssd1306_gddram[(y + i) * 128 + x + j]), );
    }
    __iic_stop();
  }
}
void ssd1306_init(void) {
  __iic_start();
  __ASSERT_RETURN(!__iic_write_byte(__SSD1306_DEVICE_ADDR << 1), );
  __ASSERT_RETURN(!__iic_write_byte(__SSD1306_ONLY_DATA | __SSD1306_COMMAND), );
  __ASSERT_RETURN(!__iic_write_byte(__SSD1306_SetDisplayOff), );
  // __iic_write_addr_byte(__SSD1306_COMMAND, __SSD1306_SetLowerColumnStartAddForPageMode);
  // __iic_write_addr_byte(__SSD1306_COMMAND, __SSD1306_SetHigherColumnStartAddForPageMode);
  // __iic_write_addr_byte(__SSD1306_COMMAND, __SSD1306_SetDisplayStartLine);
  __ASSERT_RETURN(!__iic_write_byte(__SSD1306_SetContrastControlRegister), );
  __ASSERT_RETURN(!__iic_write_byte(0xCF), );
  __ASSERT_RETURN(!__iic_write_byte(__SSD1306_SetColumnRemapToReverse), );
  __ASSERT_RETURN(!__iic_write_byte(__SSD1306_SetRowRemapToReverse), );
  // __ASSERT_RETURN(!__iic_write_byte(__SSD1306_SetInverseDisplay), );
  // __iic_write_addr_byte(__SSD1306_COMMAND, __SSD1306_SetMultiplexRatio);
  // __iic_write_addr_byte(__SSD1306_COMMAND, 0x3F);
  // __iic_write_addr_byte(__SSD1306_COMMAND, __SSD1306_SetDisplayOffset);
  // __iic_write_addr_byte(__SSD1306_COMMAND, 0x00);
  // __iic_write_addr_byte(__SSD1306_COMMAND, __SSD1306_SetDisplayClockDivideRatioAndOscillatorFrequency);
  // __iic_write_addr_byte(__SSD1306_COMMAND, 0x80);
  __ASSERT_RETURN(!__iic_write_byte(__SSD1306_SetPrechargePeriod), );
  __ASSERT_RETURN(!__iic_write_byte(0xF1), );
  // __iic_write_addr_byte(__SSD1306_COMMAND, __SSD1306_SetCOMPinHardwareConfiguration);
  // __iic_write_addr_byte(__SSD1306_COMMAND, 0x12);
  // __iic_write_addr_byte(__SSD1306_COMMAND, __SSD1306_SetVCOMHDeselectLevel);
  // __iic_write_addr_byte(__SSD1306_COMMAND, 0x40);
  // __iic_write_addr_byte(__SSD1306_COMMAND, __SSD1306_SetAddressingMode);
  // __iic_write_addr_byte(__SSD1306_COMMAND, 0x02);
  // __iic_write_addr_byte(__SSD1306_COMMAND, __SSD1306_SetEntireDisplayOn);
  __ASSERT_RETURN(!__iic_write_byte(__SSD1306_SetChargePumpSetting), );
  __ASSERT_RETURN(!__iic_write_byte(0x14), );
  __ASSERT_RETURN(!__iic_write_byte(__SSD1306_SetDisplayOn), );
  __iic_stop();
}